# Keil uVision project Stepper.uvproj, settings and files
target DiaperStc (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Stepper +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Header
  group Startup
    ./Startup/: STARTUP.A51
  group Header
    ./Header/: diaper.h STC15F2K60S2.H
  group Source
    ./Source/: diaper.c main.c
